options:
  parameters:
    author: Manolis Bozis
    comment: |-
      works in GNU Radio Companion 3.7.13.5
      in windows 7 system
    generate_options: qt_gui
    id: QPSK_transmitter
    output_language: python
    title: QPSK Transmitter with differential coding
  states: {}

blocks:
- name: Carrier_Frequency
  id: variable
  parameters:
    value: 1.24e9
  states: {}
- name: Const_Pnts
  id: variable
  parameters:
    value: epy_module_0.PSKsymbols(Mod_Ind)
  states: {}
- name: Delay
  id: variable
  parameters:
    value: int((Taps_No-1)/2)
  states: {}
- name: Mod_Ind
  id: variable
  parameters:
    value: '4'
  states: {}
- name: Points
  id: variable
  parameters:
    value: '100'
  states: {}
- name: RC_Delay
  id: variable
  parameters:
    value: sps-(2*Delay+1)%sps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: Symbol_Map
  id: variable
  parameters:
    value: epy_module_1.gray2int( int( math.log(Mod_Ind, 2.0) ) )
  states: {}
- name: Taps_No
  id: variable
  parameters:
    value: '31'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: bb_gain
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '62'
    value: '20'
    widget: dial
  states: {}
- name: frequency_offset
  id: variable_qtgui_range
  parameters:
    label: frequency_offset
    start: '0.0'
    step: '10e-9'
    stop: '1e-5'
    value: '0.0'
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    label: if_gain
    rangeType: int
    start: '1'
    step: '1'
    stop: '40'
    value: '40'
    widget: dial
  states: {}
- name: message_bytes
  id: variable
  parameters:
    value: '44153'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0.0'
    step: '0.005'
    stop: '0.2'
    value: '0.0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: rf_gain
    rangeType: int
    start: '0'
    step: '14'
    stop: '14'
    value: '14'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: timing_offset
  id: variable_qtgui_range
  parameters:
    label: timing offset
    start: '1.0'
    step: '1e-6'
    stop: '1.001'
    value: '1.0'
  states: {}
- name: transmit_rate
  id: variable
  parameters:
    value: '4000000'
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '1240000000'
  states: {}
- name: var_const
  id: variable_constellation
  parameters:
    const_points: Const_Pnts
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: Mod_Ind
    sym_map: Symbol_Map
    type: calcdist
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: C:\Users\tast2129\Downloads\hello_grooving_shredders.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '4'
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: int(math.log(Mod_Ind, 2))
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: Const_Pnts
  states: {}
- name: digital_diff_encoder_bb_0
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: Mod_Ind
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph
      # Returns a vector with the M-PSK complex symbols
      # M: Modulation index (M=2: BPSK, M=4: QPSK, etc)

      import numpy
      import cmath

      def PSKsymbols(M):
          if M==2:
             return [1, -1]
          else:
             lst = numpy.arange(M)
             return numpy.exp( (lst * 2j +1j) * cmath.pi/M )
  states: {}
- name: epy_module_1
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      # Returns a vector of a decimal set of Gray codes of n binary digits
      # n: The binary digits length of the Gray code

      def gray_code(n):
          if n <= 0:
              return []
          if n == 1:
              return ['0', '1']
          res = gray_code(n-1)
          return ['0'+s for s in res] + ['1'+s for s in res[::-1]]

      def bin_to_gray(n):
          if n == 0:
              return 0
          if n == 1:
              return 1
          a = MSB(n) # Assume MSB function exists. It find MSB of n
          b = n - 2**a
          return 2**a + bin_to_gray(2**a-1-b)

      import math
      # A simple way to find MSB
      def MSB(n):
          return int( math.log(n, 2.0) )

      def gray2int(n):
          A = []
          for k in range(2**n):
              A.append(bin_to_gray(k))
          return A
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '1240000000'
    samplerate: transmit_rate
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"QPSK Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: float(samp_rate*sps)
    fc: '0'
    fftsize: '1024'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: ''
    label2: ''
    size: sps*Points
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate
    interp: transmit_rate
    taps: ''
    type: ccc
  states: {state: bypassed}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    gain: '1'
    interp: sps
    ntaps: '54'
    samp_rate: transmit_rate
    sym_rate: Rs
    type: interp_fir_filter_ccf
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_throttle_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_diff_encoder_bb_0, '0']
- [blocks_throttle_0, '0', root_raised_cosine_filter_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_encoder_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [rational_resampler_xxx_0, '0', iio_pluto_sink_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
